# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\SPWM;..\HARDWARE\FEEDBACK;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\LED;..\HARDWARE\STMFLASH;..\HARDWARE\oled;..\HARDWARE\Key;..\HARDWARE\oled\menu;..\HARDWARE\oled\OLED(SPI);..\HARDWARE\oled\Queue;..\HARDWARE\oled\Stack
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPWM/: spwm.c
    ../HARDWARE/FEEDBACK/: feedback.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/oled/Stack/: stack.c
    ../HARDWARE/oled/menu/: menu.c
    ../HARDWARE/oled/OLED(SPI)/: oled.c
    ../HARDWARE/oled/Queue/: Queue.c
    ../HARDWARE/Key/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
